# Pin nnstreamer instead of meta-neural-network's AUTOREV (main, 2026-11-15).
SRCREV = "526d59de1c5085a029d63107aef762f4791e214e"
