# Pin ml-api instead of meta-neural-network's AUTOREV (main, 2026-09-17).
SRCREV = "d0a687d405a0e04fba8c7507f1a212244fe3d4b9"
