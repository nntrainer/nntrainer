# meta-neural-network sets LICENSE = "BSD", which is not an SPDX license id,
# so scarthgap's do_create_spdx fails. OpenBLAS's LICENSE file is BSD-3-Clause.
LICENSE = "BSD-3-Clause"
